SUMMARY = "Bibliothèque tg-ops pour Python"
HOMEPAGE = "https://pypi.org/project/tg-ops/"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=62613a1f917f5c7bbe3176543be90c1e"

inherit pypi python_poetry_core

PYPI_PACKAGE = "tg_ops"

SRC_URI[sha256sum] = "6e4d3008bf5eaa2c4e5a5a1432bccf5f85f2cba02f9443106cd1a2f92488785c"
