FILESEXTRAPATHS:prepend := "${THISDIR}:"

SRC_URI:append = " file://server-deps.cfg"
